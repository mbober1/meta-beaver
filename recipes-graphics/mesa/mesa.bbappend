PACKAGECONFIG:stm32mp15-disco = " \
  opengl egl gles gbm \
  gallium \
  etnaviv \
  kmsro \
"
