FILESEXTRAPATHS:prepend:beaveros := "${THISDIR}/${PN}:"
